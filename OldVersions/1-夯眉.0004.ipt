# Autodesk Inventor part: 1-본체
## iProperties
Created: 2015-06
Part Number: 1-본체
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
